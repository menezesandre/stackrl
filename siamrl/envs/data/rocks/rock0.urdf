Commit message: Restructure stack envs

File: siamrl/envs/data/rocks/rock0.urdf (robot description, URDF)
Before this commit: robot rock1, 1 links, 0 joints
Links:
- link link: mass 0.246 -> 0.13147990289545625; geometry collision mesh filename=rock0.obj; visual mesh filename=rock0.obj
